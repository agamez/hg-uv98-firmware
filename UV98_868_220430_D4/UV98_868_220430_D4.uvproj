# Keil uVision project UV98_868_220430_D4.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: UV98_868_220430_D4 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: MAIN\;.\SENSOR
  group MAIN
    ./MAIN/: GPRS_51GATE.c STC_EEPROM.C PUBLIC_BUF.C DELAY.C ADC.C tostring.c
  group RF
    ./MAIN/: KISS_DECODE.C BEACON.C DIGI.C CRC16.C APRS_RF.C MICE_CODE.C MICE_DECODE.C KISS2GAOMIN.C KISS_Analysis.C KISS2ASC.C
  group README
    ./MAIN/: README.C
  group GPS
    ./MAIN/: GPS_CHECKSUM.C GPS2.C GPS_JULI.C DISP_GPS.C
  group UART
    ./MAIN/: UART1.C UART2.C UART3.C UART4.C UARTX.C
  group CMX865
    ./MAIN/: CMX865A_SPI.C CMX865A_CODE.C CMX865A_DECODE.C
  group AT24C512
    ./MAIN/: AT24C512.c BEACON_SAVE.C
  group BLUETOOTH
    ./MAIN/: BT.C
  group FUN_B
    ./MAIN/: FUN_B.C
  group FUN_C
    ./MAIN/: FUN_C.C
  group RADIO
    ./MAIN/: CHx.C
  group SENSOR
    ./SENSOR/: bmp280.c
